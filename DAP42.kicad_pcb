# Repository SushiBits/DAP42

File README.md:

# DAP42 Mini Debug Probe for ARM

A simple yet full featured CMSIS-DAP debug probe for ARM Cortex processors.

## Introduction

This project is inspired by [the original DAP42 project][DAP42]. There are some
additional features implemented on top of the original project:

*   Full JTAG support. This is useful in a daisy-chained JTAG scenario.
*   When operating in SWD mode, it supports SWO trace.
*   USB MSC support with SPI Flash. This can be used to implement either built
    in driver disk, or as a production programming tool.
*   A button and an active-high control signal, allowing the device being used
    as a production programming tool.

## License and contact

This is open source hardware under [3-clause BSD license][3BSDL].

[DAP42]: https://github.com/devanlai/dap42
[3BSDL]: LICENSE.md

## KiCad design DAP42.kicad_pcb

Parts:
C1, C2: 22p; C_0603_HandSoldering
C3, C4, C6, C8, C10: 100n; C_0603_HandSoldering
C5, C9: 10µ; C_0805_HandSoldering
C7: 47u; C_1206_HandSoldering
D1: TL431DBZ; SOT-23_Handsoldering
D2: Power; LED_D3.0mm
D3: Activity; LED_D3.0mm
D4: Error; LED_D3.0mm
F1: 500mA; R_0805_HandSoldering
J1: JTAG; Pin_Header_Straight_2x05_Pitch1.27mm_SMD
J2: Target JTAG; Multicomp_MC9A22-2034_2x10x2.54mm_Angled
J3: USB_B
L1: 120; L_0603_HandSoldering
R1, R2, R3, R4, R5: 10k; R_0603_HandSoldering
R6: 22; R_0603_HandSoldering
RN1: R_Pack04; R_Array_Convex_4x0603
SW1: RESET; SW_SPST_FSMSM
SW2: WKUP; SW_SPST_FSMSM
U1: W25Q128FV; SOIJ-8_5.3x5.3mm_Pitch1.27mm
U2: STM32F042K6Tx; LQFP-32_7x7mm_Pitch0.8mm
U3, U4: LD3985G33R; TSOT-23-5_HandSoldering
Y1: 8MHz; Crystal_SMD_5032-2pin_5.0x3.2mm_HandSoldering

Connections:
+5V: C3.1, C6.1, C7.1, F1.1, U3.1 (VIN), U4.1 (VIN), U4.3 (INH); also elsewhere on the board
/ADC_CAL: D1.1 (K), D1.2 (REF), R6.2, U2.15
/DBG_TCK: J1.4, U2.24
/DBG_TMS: J1.2, U2.23
/DBG_~RST: J1.10, R2.2, SW1.2 (B), U2.4
/ESD1/D0: J2.18; also elsewhere on the board
/ESD1/D1: J2.20; also elsewhere on the board
/ESD1B/D0: J3.2 (D-); also elsewhere on the board
/ESD1B/D1: J3.3 (D+); also elsewhere on the board
/ESD2/D0: J2.3; also elsewhere on the board
/ESD2/D1: J2.5; also elsewhere on the board
/ESD2/D2: J2.7; also elsewhere on the board
/ESD2/D3: J2.9; also elsewhere on the board
/ESD2B/D0: J2.11; also elsewhere on the board
/ESD2B/D1: J2.13; also elsewhere on the board
/ESD2B/D2: J2.15; also elsewhere on the board
/ESD2B/D3: J2.16; also elsewhere on the board
/SPI_MISO: U1.2 (MISO), U2.27
/SPI_MOSI: U1.5 (MOSI), U2.28
/SPI_NSS: U1.1 (~CS), U2.25
/SPI_SCK: U1.6 (SCK), U2.26
/SYS_ACT: D3.1 (K), U2.19
/SYS_BTN: R5.1, SW2.2 (B), U2.6; also elsewhere on the board
/SYS_ERR: D4.1 (K), U2.20
/SYS_XIN: C1.1, U2.2, Y1.1
/SYS_XOUT: C2.1, U2.3, Y1.2
/TGT_PEN: U2.18, U3.3 (INH)
/TGT_RTCK: U2.8; also elsewhere on the board
/TGT_RXD: U2.29; also elsewhere on the board
/TGT_TCK: U2.10; also elsewhere on the board
/TGT_TDI: U2.12; also elsewhere on the board
/TGT_TDO: U2.9; also elsewhere on the board
/TGT_TMS: U2.11; also elsewhere on the board
/TGT_TXD: U2.30; also elsewhere on the board
/TGT_VDD: C5.1, J2.1, J2.2, R3.1, U3.5 (VOUT); also elsewhere on the board
/TGT_VDDS: R3.2, R4.1, U2.14
/TGT_~RST: U2.7; also elsewhere on the board
/TGT_~TRST: U2.13; also elsewhere on the board
/USB_D+: U2.22; also elsewhere on the board
/USB_D-: U2.21; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D1.3 (A), D2.1 (K), J1.3, J1.5, J1.9, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J3.4 (GND), J3.5 (Shield), R1.2, R4.2, R5.2, SW1.1 (A), U1.4 (GND), U2.16, U2.32, U3.2 (GND), U4.2 (GND); also elsewhere on the board
unnamed: C4.1, U3.4 (BYP)
unnamed: C8.1, U4.4 (BYP)
unnamed: D2.2 (A), RN1.5 (R4.2)
unnamed: D3.2 (A), RN1.7 (R2.2)
unnamed: D4.2 (A), RN1.8 (R1.2)
unnamed: F1.2, J3.1 (VBUS)
unnamed: R1.1, U2.31
VDD: C9.1, J1.1, L1.1, R2.1, R6.1, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN1.4 (R4.1), SW2.1 (A), U1.3 (~WP), U1.7 (~HOLD), U1.8 (Vcc), U2.1, U2.17, U4.5 (VOUT)
VDDA: C10.1, L1.2, U2.5

Parts:
RN2: 510; R_Array_Convex_4x0603
U5, U6: USBLC6-2SC6; SOT-23-6_Handsoldering

Connections:
/ESD2/D0: U5.6 (IO1); also elsewhere on the board
/ESD2/D1: U5.4 (IO2); also elsewhere on the board
/ESD2/D2: U6.6 (IO1); also elsewhere on the board
/ESD2/D3: U6.4 (IO2); also elsewhere on the board
/TGT_TCK: RN2.4 (R4.1); also elsewhere on the board
/TGT_TDI: RN2.2 (R2.1); also elsewhere on the board
/TGT_TMS: RN2.3 (R3.1); also elsewhere on the board
/TGT_VDD: U5.5 (VBUS), U6.5 (VBUS); also elsewhere on the board
/TGT_~TRST: RN2.1 (R1.1); also elsewhere on the board
GND: U5.2 (GND), U6.2 (GND); also elsewhere on the board
unnamed: RN2.5 (R4.2), U6.3 (IO2)
unnamed: RN2.6 (R3.2), U6.1 (IO1)
unnamed: RN2.7 (R2.2), U5.3 (IO2)
unnamed: RN2.8 (R1.2), U5.1 (IO1)

Parts of its further copies:
RN3: 510; R_Array_Convex_4x0603
U7, U8: USBLC6-2SC6; SOT-23-6_Handsoldering

Connections of its further copies:
/ESD2B/D0: U7.6 (IO1); also elsewhere on the board
/ESD2B/D1: U7.4 (IO2); also elsewhere on the board
/ESD2B/D2: U8.6 (IO1); also elsewhere on the board
/ESD2B/D3: U8.4 (IO2); also elsewhere on the board
/SYS_BTN: RN3.4 (R4.1); also elsewhere on the board
/TGT_RTCK: RN3.1 (R1.1); also elsewhere on the board
/TGT_TDO: RN3.2 (R2.1); also elsewhere on the board
/TGT_VDD: U7.5 (VBUS), U8.5 (VBUS); also elsewhere on the board
/TGT_~RST: RN3.3 (R3.1); also elsewhere on the board
GND: U7.2 (GND), U8.2 (GND); also elsewhere on the board
unnamed: RN3.5 (R4.2), U8.3 (IO2)
unnamed: RN3.6 (R3.2), U8.1 (IO1)
unnamed: RN3.7 (R2.2), U7.3 (IO2)
unnamed: RN3.8 (R1.2), U7.1 (IO1)

Parts:
RN4: 510; R_Array_Convex_4x0603
U9: USBLC6-2SC6; SOT-23-6_Handsoldering

Connections:
/ESD1/D0: U9.6 (IO1); also elsewhere on the board
/ESD1/D1: U9.4 (IO2); also elsewhere on the board
/TGT_RXD: RN4.3 (R3.1); also elsewhere on the board
/TGT_TXD: RN4.2 (R2.1); also elsewhere on the board
/TGT_VDD: U9.5 (VBUS); also elsewhere on the board
GND: U9.2 (GND); also elsewhere on the board
unnamed: RN4.6 (R3.2), U9.3 (IO2)
unnamed: RN4.7 (R2.2), U9.1 (IO1)

Parts of its further copies:
RN5: 510; R_Array_Convex_4x0603
U10: USBLC6-2SC6; SOT-23-6_Handsoldering

Connections of its further copies:
+5V: U10.5 (VBUS); also elsewhere on the board
/ESD1B/D0: U10.6 (IO1); also elsewhere on the board
/ESD1B/D1: U10.4 (IO2); also elsewhere on the board
/USB_D+: RN5.3 (R3.1); also elsewhere on the board
/USB_D-: RN5.2 (R2.1); also elsewhere on the board
GND: U10.2 (GND); also elsewhere on the board
unnamed: RN5.6 (R3.2), U10.3 (IO2)
unnamed: RN5.7 (R2.2), U10.1 (IO1)

Board: 2 copper layers, 64.0 x 39.0 mm, 43 parts (0 on the bottom side), 62 nets.

## Commit log

2017-11-03 Preparing version 1 release
2017-11-09 Changing the power delivery subsystem.
2017-11-09 STM32F1 branch: creating a F103 mockup
2017-11-09 Updated README to cover the purpose of stm32f1 branch.
2017-11-09 README update to reflect on the new branch.
2017-12-07 Adding title block contents

Notices in the files:
DAP42.kicad_pcb:
© 2017 Max Chan
